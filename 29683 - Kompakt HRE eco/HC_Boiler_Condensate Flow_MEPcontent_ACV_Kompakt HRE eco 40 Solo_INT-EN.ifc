Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2021-05-25T15:27:21
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue May 25 15:27:21 2021 * Host: RVIDREA-RO-LE * Database: C:\Users\RVidrea\AppData\Local\Temp\{CE7FD319-684C-4792-9559-DF0A34A56048}\ifc * Database version: 5507 * Database creation date: Tue May 25 15:27:20 2021 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Tue May 25 15:27:20 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue May 25 15:27:20 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Floor Level
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: V00; Structural: no
Other - Category: Levels; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Constraints(Type) - Elevation Base: Project Base Point

# IfcBoiler: Kompakt HRE eco 40 Solo, HC_Boiler_Condensate Flow_MEPcontent_ACV_Kompakt HRE eco_12-40 Solo_INT-EN:Kompakt HRE eco 40 Solo:1406632
In: V00
Type - PredefinedType: WATER; Material: Color RGB 222-222-222, Color RGB 237-028-036, Color RGB 040-040-040, Color RGB 073-073-073, Color RGB 155-155-155
Type - Dimensions - Depth: 247 mm; Drain Diameter: 25 mm; Gas Diameter: 12.7 mm; Height: 710 mm; Hydronic Diameter: 19.05 mm; Use Nominal Diameter: yes; Width: 450 mm
Type - Electrical - Input: 42500 W; Max Power Boiler: 40900 W; Min Power Boiler: 8100 W; Voltage: 230 V
Type - Electrical - Loads - Power: 35 W
Type - Identity Data - Article Type: Kompakt HRE eco 40 Solo; Base Family Version: 12.27; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: High efficiency wall mounted gas condensing boiler; EMCS Version: 4.0; ETIM Article Class: EC010082; Family Version: 12.27; GLN: 5400891000007; Manufacturer: ACV; Manufacturer URL: https://www.acv.com/international/customer/dl/4642; MEPcontent Class: BOILER; Model: Kompakt HRE eco 40 Solo; OmniClass Number: 23.75.10.11.14; OmniClass Title: Hot Water Heat Generators; Revit Version: 2018; Type Name: Kompakt HRE eco 40 Solo; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Dark Grey: Color RGB 073-073-073; Grey: Color RGB 155-155-155; White: Color RGB 222-222-222
Type - Mechanical - Gas Flow Rate Max: 0.00122222 m3/s; Maximum Supply Temperature (Operating Temperature): 90 kg/K/s3; Max Pressure Heating: 300000 Pa; Weight: 36
Type - Other - Category: Mechanical Equipment; B: 637 mm; Chimney Agreement: B23-B33-C13-C33-C43-C53-C63-C83-C93; Class: 44; Family Name: HC_Boiler_Condensate Flow_MEPcontent_ACV_Kompakt HRE eco_12-40 Solo_INT-EN; Space Heating Energy Efficiency Class: A
Type - Text - Article Description: High efficiency wall mounted gas condensing boiler; GTIN: 5400891034149; Manufacturer Art. No.: A1003090; Pipe Type Category: M561; Product Line: Kompakt HRE eco
Pset_ManufacturerTypeInformation - Manufacturer: ACV
Constraints - Offset: 0 mm
Dimensions - Air Supply Diameter: 100 mm; Area: 0.724263 m2; Flue Gas Diameter: 60 mm; Volume: 0.0755083 m3
Identity Data - Mark: 4
Mechanical - Air Supply Flow: 0 m3/s; Drain Fixture Units: 0; Flue Gas Flow: 0 m3/s; Gas Flow: 0 m3/s; Hydronic Return Flow: 0 m3/s; Hydronic Supply Flow: 0 m3/s; System Classification: Hydronic Supply,Hydronic Return,Sanitary,Other,Power
Other - Family: HC_Boiler_Condensate Flow_MEPcontent_ACV_Kompakt HRE eco_12-40 Solo_INT-EN: Kompakt HRE eco 40 Solo; Family and Type: HC_Boiler_Condensate Flow_MEPcontent_ACV_Kompakt HRE eco_12-40 Solo_INT-EN: Kompakt HRE eco 40 Solo; Flue Gas Connection Depth: 170 mm; Flue Gas Radius: 30 mm; Supply Air Radius: 50 mm; Supply Air Reference Line Depth: 170 mm; Supply Air Reference Line Length: 210 mm; Supply Air Reference Line Width: 138 mm; Type: HC_Boiler_Condensate Flow_MEPcontent_ACV_Kompakt HRE eco_12-40 Solo_INT-EN: Kompakt HRE eco 40 Solo; Type Id: HC_Boiler_Condensate Flow_MEPcontent_ACV_Kompakt HRE eco_12-40 Solo_INT-EN: Kompakt HRE eco 40 Solo
Phasing - Phase Created: 4. Plan over 10 jaar
Visibility - Concentric Connection: yes; Parallel Connection: no
