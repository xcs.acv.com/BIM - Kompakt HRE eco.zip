Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2021-05-25T15:27:31
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue May 25 15:27:31 2021 * Host: RVIDREA-RO-LE * Database: C:\Users\RVidrea\AppData\Local\Temp\{A37F6099-480F-44EB-A353-E530187F54CF}\ifc * Database version: 5507 * Database creation date: Tue May 25 15:27:30 2021 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Tue May 25 15:27:30 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue May 25 15:27:30 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Floor Level
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: V00; Structural: no
Other - Category: Levels; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Constraints(Type) - Elevation Base: Project Base Point

# IfcBoiler: Kompakt HRE eco 18-24, HC_Boiler_Condensate Flow_MEPcontent_ACV_Kompakt HRE eco_18-30_INT-EN:Kompakt HRE eco 18-24:1408981
In: V00
Type - PredefinedType: WATER; Material: Color RGB 222-222-222, Color RGB 237-028-036, Color RGB 040-040-040, Color RGB 073-073-073, Color RGB 155-155-155
Type - Dimensions - Depth: 247 mm; Domestic Diameter: 12.7 mm; Drain Diameter: 25 mm; Gas Diameter: 12.7 mm; Height: 590 mm; Hydronic Diameter: 19.05 mm; Use Nominal Diameter: yes; Width: 450 mm
Type - Electrical - Input: 22100 W; Max Power Boiler: 17800 W; Min Power Boiler: 5400 W; Voltage: 230 V
Type - Identity Data - Article Type: Kompakt HRE eco 18-24; Base Family Version: 12.27; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: High efficiency wall mounted gas condensing boiler. Also condensing on DHW mode; EMCS Version: 4.0; ETIM Article Class: EC010082; Family Version: 12.27; GLN: 5400891000007; Manufacturer: ACV; Manufacturer URL: https://www.acv.com/international/customer/dl/3462; MEPcontent Class: BOILER; Model: Kompakt HRE eco 18-24; OmniClass Number: 23.75.10.11.14; OmniClass Title: Hot Water Heat Generators; Revit Version: 2018; Type Name: Kompakt HRE eco 18-24; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Dark Grey: Color RGB 073-073-073; Grey: Color RGB 155-155-155; White: Color RGB 222-222-222
Type - Mechanical - Gas Flow Rate Max: 0.000638889 m3/s; Maximum Supply Temperature (Operating Temperature): 90 kg/K/s3; Max Pressure Heating: 300000 Pa; Weight: 30
Type - Other - Category: Mechanical Equipment; B: 517 mm; Chimney Agreement: B23-B33-C13-C33-C43-C53-C63-C83-C93; Class: 44; Family Name: HC_Boiler_Condensate Flow_MEPcontent_ACV_Kompakt HRE eco_18-30_INT-EN; Profile: L; Space Heating Energy Efficiency Class: A; Water Heating Energy Efficiency Class: A
Type - Text - Article Description: High efficiency wall mounted gas condensing boiler. Also condensing on DHW mode; GTIN: 5400891002988; Manufacturer Art. No.: 08658801; Pipe Type Category: M561; Product Line: Kompakt HRE eco
Pset_ManufacturerTypeInformation - Manufacturer: ACV
Constraints - Offset: 0 mm
Dimensions - Air Supply Diameter: 100 mm; Area: 0.648695 m2; Flue Gas Diameter: 60 mm; Volume: 0.0628469 m3
Electrical - Loads - Power: 35 W
Identity Data - Design Option: Main Model; Mark: 4
Mechanical - Air Supply Flow: 0 m3/s; Domestic Cold Water Flow: 0 m3/s; Domestic Hot Water Flow: 0 m3/s; Drain Fixture Units: 0; Flue Gas Flow: 0 m3/s; Gas Flow: 0 m3/s; Hydronic Return Flow: 0 m3/s; Hydronic Supply Flow: 0 m3/s; System Classification: Hydronic Supply,Hydronic Return,Sanitary,Other,Power,Domestic Hot Water,Domestic Cold Water
Other - Family: HC_Boiler_Condensate Flow_MEPcontent_ACV_Kompakt HRE eco_18-30_INT-EN: Kompakt HRE eco 18-24; Family and Type: HC_Boiler_Condensate Flow_MEPcontent_ACV_Kompakt HRE eco_18-30_INT-EN: Kompakt HRE eco 18-24; Flue Gas Connection Depth: 170 mm; Flue Gas Radius: 30 mm; Supply Air Radius: 50 mm; Supply Air Reference Line Depth: 170 mm; Supply Air Reference Line Length: 210 mm; Supply Air Reference Line Width: 138 mm; Type: HC_Boiler_Condensate Flow_MEPcontent_ACV_Kompakt HRE eco_18-30_INT-EN: Kompakt HRE eco 18-24; Type Id: HC_Boiler_Condensate Flow_MEPcontent_ACV_Kompakt HRE eco_18-30_INT-EN: Kompakt HRE eco 18-24
Phasing - Phase Created: 4. Plan over 10 jaar
Visibility - Concentric Connection: yes; Parallel Connection: no
